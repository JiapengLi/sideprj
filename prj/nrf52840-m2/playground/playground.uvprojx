# Keil uVision project playground.uvprojx, settings and files
target playground (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: playground +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: __LINT__=1 NRF52_SERIES DEVELOP_IN_NRF52840
  c include: ..\..\..\src\hal\mcu\cmsis\include;..\..\..\src\hal\mcu\nrf\nrfx\mdk;..\..\..\src\hal\user\nrf52;..\..\..\src\hal\board\nrf52840-m2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  group app
    ../../../src/app/playground/nrf52840-m2/: main.c
  group hal/mcu/bsp
    ../../../src/hal/mcu/nrf/nrfx/mdk/: system_nrf52840.c arm_startup_nrf52840.s
  group hal/board
    ../../../src/hal/board/nrf52840-m2/: hal.c
  group hal/user
    ../../../src/hal/user/nrf52/: hal-gpio.c hal-clk.c hal-systick-emu.c hal-uart.c
